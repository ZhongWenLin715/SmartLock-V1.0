# Keil uVision project AS608.uvprojx, settings and files
target AS608 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AS608 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\TIMER;..\HARDWARE\AS608;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\USART2;..\HARDWARE\USART;..\HARDWARE\TIMER2;..\HARDWARE\ADC;..\HARDWARE\USART3;..\HARDWARE\TIMER3;..\Gizwits
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TIMER2/: timer2.c
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
  group Gizwits
    ../Gizwits/: common.c dataPointTools.c gizwits_product.c gizwits_protocol.c ringbuffer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c misc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_adc.c
  group README
    ../: README.TXT
